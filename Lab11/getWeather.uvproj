# Keil uVision project getWeather.uvproj, settings and files
target getWeather (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: getWeather
  AfterMake: fromelf --bin --output .\rvmdk\cc31000_starter.bin .\rvmdk\cc31000_starter.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM _POSIX_SOURCE UART_BUFFERED TARGET_IS_TM4C123_RB1, MPL_LOG_NDEBUG=1,MPU6050,EMPL,USE_DMP,EMPL_TARGET_STM32F4
  c misc: --c99
  c include: ..;..\;..\..\..\..;..\cc3100;..\cc3100\platform\ek-tm4c123gxl;..\cc3100\simplelink\include;..\cc3100\simplelink\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: cc31000_starter.sct
  link misc: --entry Reset_Handler
  group Source
    ./: main.c LED.c startup_rvmdk.S ST7735.c ADCSWTrigger.c Timers.c i2c.c MPU6050.c SysTick.c PLL.c switch.c sense.c PWM.c
    ../cc3100/platform/ek-tm4c123gxl/: board.c spi.c uart.c
    ../utils/: uartstdio.c ustdlib.c
    ./motorLib/: motor.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
